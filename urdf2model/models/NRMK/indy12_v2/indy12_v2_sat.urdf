Commit message: update

File: urdf2model/models/NRMK/indy12_v2/indy12_v2_sat.urdf (robot description, URDF)
Before this commit: robot indy12_v2_sat, 22 links, 21 joints
Links:
- link tool_plange: mass 2.6 -> 0.300
